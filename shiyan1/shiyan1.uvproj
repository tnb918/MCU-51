# Keil uVision project shiyan1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: shiyanHSc
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: shiyan1_1.s shiyan1_2.s yanshi.s shiyan1_1.c shiyan1_2.c yanshi.c shiyan1_3.s shiyan1_3.c
