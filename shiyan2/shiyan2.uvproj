# Keil uVision project shiyan2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: shiyan22s +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: shiyan2_1.c shiyan2_1.s shiyan2_2.c shiyan2_2.s shiyan2_3.c
