# Keil uVision project shiyan3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: shiyan3_3c +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: shiyan3_11.c shiyan3_12.c shiyan3_11.s shiyan3_12.s shiyan3_2.s shiyan3_2.c shiyan3_3.c
